options:
  parameters:
    generate_options: qt_gui
    id: rptr
    output_language: python
    title: NBFM_Repeater
  states: {}

blocks:
- name: RSSI
  id: variable_qtgui_label
  parameters:
    label: 'RSSI dBm:'
    type: raw
    value: rs
  states: {}
- name: beacon_att
  id: variable
  parameters:
    value: rpt.beacon_att(rx_status)
  states: {}
- name: beacon_status
  id: variable
  parameters:
    value: rpt.status(func_prb_beacon_busy)
  states: {}
- name: buffer
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: conf_ctcss
  id: variable_config
  parameters:
    config_file: ./rptr.ini
    option: ctcss
    section: main
    type: real
    value: '0.0'
    writeback: pl_freq
  states: {}
- name: conf_freq
  id: variable_config
  parameters:
    config_file: ./rptr.ini
    option: freq
    section: main
    type: int
    value: '145000000'
    writeback: freq
  states: {}
- name: conf_hangtime
  id: variable_config
  parameters:
    config_file: ./rptr.ini
    option: hangtime
    section: main
    type: int
    value: '1300'
    writeback: delay
  states: {}
- name: conf_offset
  id: variable_config
  parameters:
    config_file: ./rptr.ini
    option: offset
    section: main
    type: real
    value: '-60000'
    writeback: offset
  states: {}
- name: conf_squelch
  id: variable_config
  parameters:
    config_file: ./rptr.ini
    option: squelch
    section: main
    type: real
    value: '-40'
    writeback: sq_lvl
  states: {}
- name: conf_trxcal
  id: variable_config
  parameters:
    config_file: ./rptr.ini
    option: trxcal
    section: main
    type: int
    value: '1400'
    writeback: oscref
  states: {}
- name: ctcss_en
  id: variable
  parameters:
    value: rpt.ctcss_en(pl_freq)
  states: {}
- name: ctcss_status
  id: variable
  parameters:
    value: rpt.status(func_ctcssdec)
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: TX Coda ms
    min_len: '10'
    rangeType: int
    start: '100'
    step: '100'
    stop: '5000'
    value: conf_hangtime
    widget: counter
  states: {}
- name: filter_wide
  id: variable_qtgui_range
  parameters:
    label: Filter
    min_len: '50'
    rangeType: int
    start: '4000'
    step: '1000'
    stop: '12000'
    value: '7500'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq TX
    min_len: '100'
    rangeType: int
    start: '144000000'
    step: '12500'
    stop: '1300000000'
    value: conf_freq
    widget: counter
  states: {}
- name: func_bfbusy
  id: variable_function_probe
  parameters:
    block_id: prb_bfbusy
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: func_ctcssdec
  id: variable_function_probe
  parameters:
    block_id: prb_ctcssdec
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: func_nbfm_busy
  id: variable_function_probe
  parameters:
    block_id: prb_nbfm_busy
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: func_prb_beacon_busy
  id: variable_function_probe
  parameters:
    block_id: prb_beacon_busy
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: func_rssi
  id: variable_function_probe
  parameters:
    block_id: rssi
    function_name: level
    poll_rate: '6'
    value: '0'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Shift RX
    min_len: '100'
    start: '-10000000'
    step: '25000'
    stop: '10000000'
    value: conf_offset
    widget: counter
  states: {}
- name: oscref
  id: variable_qtgui_range
  parameters:
    label: OSC REF
    min_len: '10'
    rangeType: int
    start: '-50000'
    step: '50'
    stop: '50000'
    value: conf_trxcal
    widget: counter
  states: {}
- name: pl_freq
  id: variable_qtgui_chooser
  parameters:
    label: PL Tone
    labels: '["0.0", "67.0", "71.9", "74.4", "77.0", "79.7", "82.5", "85.4", "88.5", "91.5", "94.8", "97.4", "100.0", "103.5", "107.2", "110.9", "114.8", "118.8", "123.0", "127.3", "131.8", "136.5", "141.3", "146.2", "151.4", "156.7", "162.2", "167.9", "173.8", "179.9", "186.2", "192.8", "203.5", "210.7", "218.1", "225.7", "233.6", "241.8", "250.3"]'
    num_opts: '0'
    options: '[0.0, 67.0, 71.9, 74.4, 77.0, 79.7, 82.5, 85.4, 88.5, 91.5, 94.8, 97.4, 100.0, 103.5, 107.2, 110.9, 114.8, 118.8, 123.0, 127.3, 131.8, 136.5, 141.3, 146.2, 151.4, 156.7, 162.2, 167.9, 173.8, 179.9, 186.2, 192.8, 203.5, 210.7, 218.1, 225.7, 233.6, 241.8, 250.3]'
    type: real
    value: conf_ctcss
  states: {}
- name: pluto_gain
  id: variable
  parameters:
    value: rpt.agc(func_rssi)
  states: {}
- name: ptt
  id: variable
  parameters:
    value: rpt.hang(func_bfbusy, delay)
  states: {}
- name: rs
  id: variable
  parameters:
    value: rpt.newrssi(func_rssi)
  states: {}
- name: rx_status
  id: variable
  parameters:
    value: rpt.status(func_nbfm_busy)
  states: {}
- name: samp_bf
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_bf*9
  states: {}
- name: shift
  id: variable
  parameters:
    value: '15000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    min_len: '100'
    start: '-150'
    step: '1'
    stop: '0'
    value: conf_squelch
    widget: counter
  states: {}
- name: analog_ctcss_squelch_ff_0
  id: analog_ctcss_squelch_ff
  parameters:
    freq: pl_freq
    gate: 'False'
    len: '0'
    level: '0.015'
    ramp: '0'
    rate: samp_bf
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_bf
    max_dev: max_dev
    quad_rate: samp_rate
    tau: '7.5e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_bf
    fh: '0'
    max_dev: max_dev
    quad_rate: samp_rate
    tau: '7.5e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: (int)(-ptt)*(100)
    type: complex
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.005'
    threshold: sq_lvl+59
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_bf
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '3500'
    interp: '1'
    low_cutoff_freq: '50'
    samp_rate: samp_bf
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filter_wide
    low_cutoff_freq: '-filter_wide'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filter_wide
    low_cutoff_freq: '-filter_wide'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: shift
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: beacon_att
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-59'
    n: '10'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: ctcss_en
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: ctcss_en
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fff
    width: '25'
    win: window.WIN_HAMMING
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '200000'
    buffer_size: buffer
    cyclic: 'False'
    filter_source: '''Auto'''
    fpass: '10000'
    frequency: (int)(freq)+(oscref)
    fstop: '40000'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: buffer
    filter_source: '''Auto'''
    fpass: (float)(samp_rate)/(4)
    frequency: (int)(freq)+(shift)+(oscref)+(offset)
    fstop: (float)(samp_rate)/(3)
    gain1: '''manual'''
    manual_gain1: pluto_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: prb_beacon_busy
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: prb_bfbusy
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: prb_ctcssdec
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: prb_nbfm_busy
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_ledindicator_0_0
  id: qtgui_ledindicator
  parameters:
    label: '"TX"'
    offColor: gray
    onColor: red
    state: ptt
    verticalalignment: '3'
  states: {}
- name: qtgui_ledindicator_0_0_0
  id: qtgui_ledindicator
  parameters:
    label: '"RX"'
    offColor: gray
    state: rx_status
  states: {}
- name: qtgui_ledindicator_0_0_0_0
  id: qtgui_ledindicator
  parameters:
    label: '"CTCSS"'
    offColor: gray
    onColor: yellow
    state: ctcss_status
    verticalalignment: '3'
  states: {}
- name: qtgui_ledindicator_0_0_0_0_0
  id: qtgui_ledindicator
  parameters:
    label: '"BEACON"'
    offColor: gray
    onColor: lime
    state: beacon_status
    verticalalignment: '2'
  states: {}
- name: rpt
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      import math
      import os

      ###########################################################################
      #                       Global variable -> delay():                       #
      ###########################################################################

      t = 0
      f = 0
      d = 0
      gpo_status = 0
      tx = '3'
      ###########################################################################
      #                      Global variable -> newrssi():                      #
      ###########################################################################

      g = 73


      ###########################################################################
      #                             Funtion hang TX                             #
      ###########################################################################
      def hang(probe, delay):
      	global t, f, d, gpo_status, tx
      	if probe:
      		probe = probe
      	else:
      		probe = 0

      	if probe != 0:
      		t = 1
      		f = 1
      		d = 0
      		if gpo_status == 0:
      			os.system('iio_attr -u ip:pluto.local -D ad9361-phy gpo_set  3-1')
      			gpo_status = 1
      	elif f == 1 and probe == 0:
      		if d < (delay):
      			d = d + 100
      			t = 1
      			f = 1
      		else:
      			t = 0
      			f = 0
      			d = 0
      			if gpo_status == 1:
      				os.system('iio_attr -u ip:pluto.local -D ad9361-phy gpo_set 3-0')
      				gpo_status = 0
      	return t

      ############################################################################
      #			     Function AGC regolate gain Pluto                          #
      ############################################################################
      def agc(rssi):
      	global g
      	sa = math.trunc(rssi)
      	if sa > -73:
      		g = g - 6
      	elif sa < -88:
      		if g <= 67:
      			g = g + 6
      		else:
      			g = 73
      	else:
      		g = g
      	return g

      ###########################################################################
      #			     Function new RSSI with addition agc                      #
      ###########################################################################
      def newrssi(s):
      	global g
      	ss = math.trunc(s)
      	ns = ss + (73 - g)
      	return ns

      ###########################################################################
      #                         trigger status input                            #
      ###########################################################################
      def status(input):
      	if input != 0:
      		return 1
      	else:
      		return 0

      ###########################################################################
      #                         CTCSS enable disable                            #
      ###########################################################################
      def ctcss_en(input):
      	if input > 0.0:
      		return 0
      	else:
      		return 1

      ###########################################################################
      #              Audio beacon attenuation 20dB if RX is ON                  #
      ###########################################################################		
      def beacon_att(input):
      	if input == 0:
      		return 1
      	else:
      		return 0.1

      ###########################################################################
      #                                 END                                     #
      ###########################################################################
  states: {}
- name: rssi
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:pluto.local
  states: {}

connections:
- [analog_ctcss_squelch_ff_0, '0', blocks_selector_0_0, '0']
- [analog_ctcss_squelch_ff_0, '0', prb_ctcssdec, '0']
- [analog_nbfm_rx_0, '0', blocks_selector_0, '0']
- [analog_nbfm_rx_0, '0', prb_nbfm_busy, '0']
- [analog_nbfm_tx_0, '0', analog_pwr_squelch_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', band_pass_filter_0_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', prb_beacon_busy, '0']
- [band_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [band_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_add_xx_0, '0', prb_bfbusy, '0']
- [blocks_complex_to_mag_squared_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_freqshift_cc_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_nlog10_ff_0, '0', rssi, '0']
- [blocks_selector_0, '0', analog_ctcss_squelch_ff_0, '0']
- [blocks_selector_0, '1', blocks_selector_0_0, '1']
- [blocks_selector_0_0, '0', blocks_add_xx_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_nlog10_ff_0, '0']
- [iio_pluto_source_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
